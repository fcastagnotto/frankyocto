

IMAGE_ROOTFS_SIZE:arm = "1992294"


IMAGE_ROOTFS_SIZE:aarch64:sd8g  = "3145728"
IMAGE_ROOTFS_SIZE:aarch64:sd16g = "6291456"
IMAGE_ROOTFS_SIZE:aarch64:sd32g = "11534336"


# WKS
WKS_FILE:aarch64:sd8g  = "frank-sdcard-rauc-8g.wks"
WKS_FILE:aarch64:sd16g = "frank-sdcard-rauc-16g.wks"
WKS_FILE:aarch64:sd32g = "frank-sdcard-rauc-32g.wks"