RPROVIDES:${PN} += "u-boot-env"